# Keil uVision project FM33LG0XX_Tester.uvprojx, settings and files
target Example (6150000::V6.15::ARMCLANG)
  device: FM33LG04X FMSH
  pack: Keil.FM33LG0XX_DFP.2.0.2
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: FM33LC0xx_Tester +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: FM33LG0XX,USE_FULL_ASSERT
  c include: ..\Drivers\CMSIS\Inculde;..\Drivers\CMSIS\Device\FM\FM33xx\Include;..\Drivers\FM33LG0xx_FL_Driver\Inc;..\MF-config\Inc;..\Inc;..\rt-thread\include;..\rt-thread\components\finsh;..\rt-thread\libcpu\arm\cortex-m0
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/FM/FM33xx/Source/Templates/ARM/: startup_fm33lg0xx.s
  group Application/MF-config
    ../MF-config/Src/: mf_config.c
  group Application/User
    ../Src/: main.c user_init.c TestRTC.c board.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/FM/FM33xx/Source/: system_fm33lg0xx.c
  group Drivers/FM33LG0xx_FL_Driver
    ../Drivers/FM33LG0xx_FL_Driver/Src/: fm33lg0xx_fl.c fm33lg0xx_fl_adc.c fm33lg0xx_fl_aes.c fm33lg0xx_fl_atim.c fm33lg0xx_fl_bstim16.c fm33lg0xx_fl_bstim32.c fm33lg0xx_fl_can.c fm33lg0xx_fl_cmu.c fm33lg0xx_fl_comp.c fm33lg0xx_fl_crc.c fm33lg0xx_fl_dac.c fm33lg0xx_fl_divas.c fm33lg0xx_fl_dma.c fm33lg0xx_fl_flash.c fm33lg0xx_fl_gpio.c fm33lg0xx_fl_gptim.c fm33lg0xx_fl_i2c.c fm33lg0xx_fl_iwdt.c fm33lg0xx_fl_lcd.c fm33lg0xx_fl_lptim16.c fm33lg0xx_fl_lptim32.c fm33lg0xx_fl_lpuart.c fm33lg0xx_fl_opa.c fm33lg0xx_fl_pgl.c fm33lg0xx_fl_pmu.c fm33lg0xx_fl_rng.c fm33lg0xx_fl_rtca.c fm33lg0xx_fl_rtcb.c fm33lg0xx_fl_spi.c fm33lg0xx_fl_svd.c fm33lg0xx_fl_u7816.c fm33lg0xx_fl_uart.c fm33lg0xx_fl_vao.c fm33lg0xx_fl_wwdt.c
  group rtt/ports
    ../rt-thread/libcpu/arm/cortex-m0/: cpuport.c context_rvds.S
  group rtt/finsh
    ../rt-thread/components/finsh/: cmd.c finsh_port.c msh.c shell.c
  group rtt/kernel
    ../rt-thread/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
target SRAM (6150000::V6.15::ARMCLANG)
  device: FM33LG04X FMSH
  pack: Keil.FM33LG0XX_DFP.2.0.2
  cpu: as above
  output: FM33LC0xx_Tester +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: FM33LG0XX,USE_FULL_ASSERT
  c include: as above
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
